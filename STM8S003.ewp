# IAR project STM8S003.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S005K6 STM8S005K6
  General.GenCodeModel: 1
  General.GenDataModel: 0
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: FWlib\inc; User
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: LCDST7735S.s19
  ILINK.IlinkOutputFile: STM8S003.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  General.GenDataModel: 1
  ICCSTM8.CCDefines: NDEBUG
  group FWlib
    FWlib/src/: stm8s_adc1.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_tim1.c stm8s_tim2.c
  group User
    User/: delay.c key.c lcdControl.c Led.c main.c TimeCtrl.c
